# Repository Frrrrrrrrrank/Underwater-Glider

## KiCad design UnderwaterGlider/UnderwaterGlider.kicad_pcb

Parts:
BZ2: Buzzer; MLT-9032
C6, C9, C67: 20p; C_0603_1608Metric
C7, C8, C10, C11, C12, C13, C16, C17, C18, C52, C54, C55, C56, C57, C58, C59, C62, C70, C71, C72, C73, C125: 100n; C_0603_1608Metric
C20, C46: 0u1; C_0603_1608Metric
C27, C124, C126, C127: 1u; C_0603_1608Metric
C60, C61: 2.2u; C_0603_1608Metric
C66, C76, C84, C85, C86, C87, C88, C120, C121, C122, C123: 10u; C_0603_1608Metric
D1: NUP2105L; SOT-23
D8, D9, D10: SM712; SOT-23
D11, D32, D33: LED; LED_0603_1608Metric
D12: DSS34; D_SMF
D23: LED_Blue; LED_0603_1608Metric
D35: 3V3 TVS; D_SMF
F2: 0.5A; Fuse_1206_3216Metric
F3: 1.2A; Fuse_1210_3225Metric
H1, H2, H3, H4: MountingHole_Pad_MP; MountingHole_3.2mm_M3_Pad_Via
J1: Micro_SD_Card_Det1; TF-SMD_TF-PUSH
J2: Conn_01x02; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
J3, J4, J21, J24: Conn_01x04_MountingPin; JST_GH_SM04B-GHS-TB_1x04-1MP_P1.25mm_Horizontal
J5, J26, J29, J30, J31: Conn_01x03_MountingPin; JST_GH_BM03B-GHS-TBT_1x03-1MP_P1.25mm_Vertical
J6, J7, J8, J9: Conn_01x03; JST_PH_B3B-PH-K_1x03_P2.00mm_Vertical
J11, J12, J13, J14, J15, J16, J17, J18: Conn_01x02_MountingPin; JST_GH_SM02B-GHS-TB_1x02-1MP_P1.25mm_Horizontal
J19: Conn_01x04_MountingPin; JST_GH_BM04B-GHS-TBT_1x04-1MP_P1.25mm_Vertical
J20: Conn_01x04; JST_PH_B4B-PH-K_1x04_P2.00mm_Vertical
J22: SBus; PinHeader_1x03_P2.54mm_Vertical
J23: Conn_01x07_MountingPin; JST_GH_BM07B-GHS-TBT_1x07-1MP_P1.25mm_Vertical
J25, J27: Conn_01x05_MountingPin; JST_GH_BM05B-GHS-TBT_1x05-1MP_P1.25mm_Vertical
J28: SWD; Molex_PicoBlade_53261-0471_1x04-1MP_P1.25mm_Horizontal
L2: 220r; L_0603_1608Metric
Q1: AO3400A; SOT-23
R1: 1M; R_0603_1608Metric
R2, R3, R4, R6, R7, R8, R9, R10, R14, R18, R41, R43, R49, R59, R61: 10k; R_0603_1608Metric
R5, R12, R16, R20: 120R; R_0603_1608Metric
R11, R13, R15, R17, R19, R21, R26, R46, R47, R48: 4k7; R_0603_1608Metric
R22, R31, R32, R85, R86: 1k; R_0603_1608Metric
R23, R58, R60: 330R; R_0603_1608Metric
R24: 100k; R_0603_1608Metric
R25, R27, R28, R30: 4.7k; R_0603_1608Metric
R42: 33r; R_0603_1608Metric
RN4, RN5, RN6, RN7, RN8, RN10, RN11, RN14, RN15, RN16, RN17, RN18, RN20, RN21, RN22, RN23: 82R; R_Array_Concave_4x0603
SW1: NRST; Panasonic_EVQPUL_EVQPUC
SW2: BOOT0; Panasonic_EVQPUL_EVQPUC
U1: STM32H743VITx; LQFP-100_14x14mm_P0.5mm
U2: MAX232; SOIC-16_4.55x10.3mm_P1.27mm
U4: TJA1042T-3; SOIC-8_3.9x4.9mm_P1.27mm
U6: TPD4E1U06DCKR; SOT-363_SC-70-6
U13, U14, U15: SN75176AD; SOIC-8_3.9x4.9mm_P1.27mm
U16: CH343P; TQFN-16-1EP_3x3mm_P0.5mm_EP1.6x1.6mm
Y1: 25MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3.3V_IO: C10.1, C27.1, C46.1, C73.2, C120.1, C123.1, J1.4 (VDD), J4.3, J23.1, J24.3, J25.1, R2.2, R3.2, R4.2, R6.2, R7.2, R8.2, R9.2, R10.1, R14.1, R18.1, R22.1, R43.2, R49.2, U4.5 (VIO), U16.1 (VIO), U16.3 (VDD5), U16.6 (V3); also elsewhere on the board
+3.3V_MCU: C52.1, C54.1, C55.1, C56.1, C57.1, C58.1, C59.1, C121.1, D35.1 (A1), F2.2, L2.2, R59.1, R85.1, SW2.2, U1.6 (VBAT), U1.11 (VDD), U1.21 (VDDA), U1.27 (VDD), U1.50 (VDD), U1.75 (VDD), U1.100 (VDD); also elsewhere on the board
+5V: BZ2.2 (-), C7.1, C8.1, C11.1, C12.1, C13.1, C16.1, C17.1, C18.1, C20.1, C66.1, C67.1, C76.1, C84.1, C85.1, C87.1, C88.1, C122.1, C124.1, C125.1, D12.1 (K), F3.1, J5.2, J19.1, J21.3, J22.2, J26.2, J29.2, J30.2, R11.1, R15.1, R19.1, R23.1, R26.1, R27.2, R46.1, R47.1, R48.1, U2.16 (VCC), U4.3 (VCC), U13.8 (VCC), U14.8 (VCC), U15.8 (VCC); also elsewhere on the board
+7.4v_Servo: J6.2, J7.2, J8.2, J9.2; also elsewhere on the board
+12V_SatellieCom: C86.1, J2.1; also elsewhere on the board
+48V: R24.2; also elsewhere on the board
/MainControl/BOOT0: C71.1, R60.1, R86.1, U1.94 (BOOT0)
/MainControl/CAN1_H: D1.2 (K), J11.2, J12.2, R5.1, U4.7 (CANH)
/MainControl/CAN1_L: D1.1 (K), J11.1, J12.1, R5.2, U4.6 (CANL)
/MainControl/CAN1_RX: RN6.7 (R2.2), U4.4 (RXD)
/MainControl/CAN1_TX: RN6.8 (R1.2), U4.1 (TXD)
/MainControl/Dir+: J3.2, RN17.6 (R3.2)
/MainControl/Dir-: J3.1, R32.2, RN17.5 (R4.2)
/MainControl/Dir_Bit: J27.1, R26.2, RN22.5 (R4.2)
/MainControl/GPIO_PA4: J23.2, RN8.8 (R1.2)
/MainControl/GPIO_PB3: J29.1, RN23.6 (R3.2)
/MainControl/GPIO_PB4: J26.1, RN23.7 (R2.2)
/MainControl/GPIO_PB5: J5.1, RN23.8 (R1.2)
/MainControl/GPIO_PC4: J23.6, RN15.8 (R1.2)
/MainControl/GPIO_PD7: J30.1, RN23.5 (R4.2)
/MainControl/I2C2_SCL: J24.2, R49.1, RN17.7 (R2.2)
/MainControl/I2C2_SDA: J24.1, R43.1, RN17.8 (R1.2)
/MainControl/LPUART1_RX: J21.1, RN10.6 (R3.2)
/MainControl/LPUART1_TX: J21.2, RN10.5 (R4.2)
/MainControl/NRST: C70.1, D32.1 (K), R58.1, U1.14 (NRST)
/MainControl/NUC1_ACT: D11.1 (K), U16.10 (ACT#)
/MainControl/NUC1_DN: J20.2, U6.3, U16.8 (USB_DN)
/MainControl/NUC1_DP: J20.3, U6.4, U16.7 (USB_DP)
/MainControl/PA1: RN8.4 (R4.1), U1.23 (PA1)
/MainControl/PA2: RN8.3 (R3.1), U1.24 (PA2)
/MainControl/PA3: RN8.2 (R2.1), U1.25 (PA3)
/MainControl/PA4: RN8.1 (R1.1), U1.28 (PA4)
/MainControl/PA5: RN15.4 (R4.1), U1.29 (PA5)
/MainControl/PA6: RN15.3 (R3.1), U1.30 (PA6)
/MainControl/PA7: RN15.2 (R2.1), U1.31 (PA7)
/MainControl/PA8: U1.67 (PA8)
/MainControl/PA9: RN7.4 (R4.1), U1.68 (PA9)
/MainControl/PA10: RN7.3 (R3.1), U1.69 (PA10)
/MainControl/PA11: U1.70 (PA11)
/MainControl/PA12: RN7.2 (R2.1), U1.71 (PA12)
/MainControl/PA13: RN7.1 (R1.1), U1.72 (PA13)
/MainControl/PA14: RN6.3 (R3.1), U1.76 (PA14)
/MainControl/PA15: U1.77 (PA15)
/MainControl/PB0: R30.2, U1.34 (PB0)
/MainControl/PB1: R24.1, R25.2, U1.35 (PB1)
/MainControl/PB2: U1.36 (PB2)
/MainControl/PB3: RN23.3 (R3.1), U1.89 (PB3)
/MainControl/PB4: RN23.2 (R2.1), U1.90 (PB4)
/MainControl/PB5: RN23.1 (R1.1), U1.91 (PB5)
/MainControl/PB6: RN10.4 (R4.1), U1.92 (PB6)
/MainControl/PB7: RN10.3 (R3.1), U1.93 (PB7)
/MainControl/PB8: RN10.2 (R2.1), U1.95 (PB8)
/MainControl/PB9: RN10.1 (R1.1), U1.96 (PB9)
/MainControl/PB10: RN17.2 (R2.1), U1.46 (PB10)
/MainControl/PB11: RN17.1 (R1.1), U1.47 (PB11)
/MainControl/PB12: RN11.4 (R4.1), U1.51 (PB12)
/MainControl/PB13: RN11.3 (R3.1), U1.52 (PB13)
/MainControl/PB14: RN14.1 (R1.1), U1.53 (PB14)
/MainControl/PB15: RN14.2 (R2.1), U1.54 (PB15)
/MainControl/PC0: U1.15 (PC0)
/MainControl/PC1: RN20.4 (R4.1), U1.16 (PC1)
/MainControl/PC2_C: RN20.3 (R3.1), U1.17 (PC2_C)
/MainControl/PC3_C: U1.18 (PC3_C)
/MainControl/PC4: RN15.1 (R1.1), U1.32 (PC4)
/MainControl/PC5: R27.1, R28.2, U1.33 (PC5)
/MainControl/PC6: U1.63 (PC6)
/MainControl/PC7: RN5.7 (R2.2), U1.64 (PC7)
/MainControl/PC8: RN5.5 (R4.2), U1.65 (PC8)
/MainControl/PC9: RN5.6 (R3.2), U1.66 (PC9)
/MainControl/PC10: RN4.5 (R4.2), U1.78 (PC10)
/MainControl/PC11: RN4.6 (R3.2), U1.79 (PC11)
/MainControl/PC12: RN4.8 (R1.2), U1.80 (PC12)
/MainControl/PC13: RN22.3 (R3.1), U1.7 (PC13)
/MainControl/PC14: RN22.2 (R2.1), U1.8 (PC14)
/MainControl/PC15: RN22.1 (R1.1), U1.9 (PC15)
/MainControl/PD0: RN6.2 (R2.1), U1.81 (PD0)
/MainControl/PD1: RN6.1 (R1.1), U1.82 (PD1)
/MainControl/PD2: RN4.7 (R2.2), U1.83 (PD2)
/MainControl/PD3: RN20.2 (R2.1), U1.84 (PD3)
/MainControl/PD4: U1.85 (PD4)
/MainControl/PD5: U1.86 (PD5)
/MainControl/PD6: U1.87 (PD6)
/MainControl/PD7: RN23.4 (R4.1), U1.88 (PD7)
/MainControl/PD8: RN18.4 (R4.1), U1.55 (PD8)
/MainControl/PD9: RN18.3 (R3.1), U1.56 (PD9)
/MainControl/PD10: U1.57 (PD10)
/MainControl/PD11: U1.58 (PD11)
/MainControl/PD12: RN18.2 (R2.1), U1.59 (PD12)
/MainControl/PD13: U1.60 (PD13)
/MainControl/PD14: RN18.1 (R1.1), U1.61 (PD14)
/MainControl/PD15: RN5.8 (R1.2), U1.62 (PD15)
/MainControl/PE0: RN14.4 (R4.1), U1.97 (PE0)
/MainControl/PE1: RN14.3 (R3.1), U1.98 (PE1)
/MainControl/PE2: U1.1 (PE2)
/MainControl/PE3: U1.2 (PE3)
/MainControl/PE4: RN22.4 (R4.1), U1.3 (PE4)
/MainControl/PE5: RN21.3 (R3.1), U1.4 (PE5)
/MainControl/PE6: RN21.1 (R1.1), U1.5 (PE6)
/MainControl/PE7: RN16.4 (R4.1), U1.37 (PE7)
/MainControl/PE8: RN16.3 (R3.1), U1.38 (PE8)
/MainControl/PE9: U1.39 (PE9)
/MainControl/PE10: RN16.2 (R2.1), U1.40 (PE10)
/MainControl/PE11: RN16.1 (R1.1), U1.41 (PE11)
/MainControl/PE12: RN17.4 (R4.1), U1.42 (PE12)
/MainControl/PE13: RN17.3 (R3.1), U1.43 (PE13)
/MainControl/PE14: U1.44 (PE14)
/MainControl/PE15: U1.45 (PE15)
/MainControl/PH0: C9.1, U1.12 (PH0), Y1.3
/MainControl/PH1: C6.1, U1.13 (PH1), Y1.1
/MainControl/Pul+: J3.4, RN16.8 (R1.2)
/MainControl/Pul-: J3.3, R31.2, RN16.7 (R2.2)
/MainControl/RS485_Bus1_A: D8.2 (A2), J13.1, J14.1, R11.2, R12.1, U13.6 (A)
/MainControl/RS485_Bus1_B: D8.1 (A1), J13.2, J14.2, R12.2, R13.1, U13.7 (B)
/MainControl/RS485_Bus2_A: D9.2 (A2), J15.1, J16.1, R15.2, R16.1, U14.6 (A)
/MainControl/RS485_Bus2_B: D9.1 (A1), J15.2, J16.2, R16.2, R17.1, U14.7 (B)
/MainControl/RS485_Bus3_A: D10.2 (A2), J17.1, J18.1, R19.2, R20.1, U15.6 (A)
/MainControl/RS485_Bus3_B: D10.1 (A1), J17.2, J18.2, R20.2, R21.1, U15.7 (B)
/MainControl/SDMMC1_CLK: J1.5 (CLK), R6.1, RN4.1 (R1.1)
/MainControl/SDMMC1_CMD: J1.3 (CMD), R4.1, RN4.2 (R2.1)
/MainControl/SDMMC1_D0: J1.7 (DAT0), R7.1, RN5.4 (R4.1)
/MainControl/SDMMC1_D1: J1.8 (DAT1), R8.1, RN5.3 (R3.1)
/MainControl/SDMMC1_D2: J1.1 (DAT2), R2.1, RN4.4 (R4.1)
/MainControl/SDMMC1_D3: J1.2 (DAT3/CD), R3.1, RN4.3 (R3.1)
/MainControl/SD_Detect: J1.9 (DET), R9.1, RN5.2 (R2.1)
/MainControl/SPI1_MISO: J23.4, RN15.6 (R3.2)
/MainControl/SPI1_MOSI: J23.5, RN15.7 (R2.2)
/MainControl/SPI1_SCK: J23.3, RN15.5 (R4.2)
/MainControl/SPI2_MISO: J25.3, RN20.6 (R3.2)
/MainControl/SPI2_MOSI: J25.2, RN20.5 (R4.2)
/MainControl/SPI2_SCK: J25.4, RN20.7 (R2.2)
/MainControl/SWD_CLK: J28.2, RN6.6 (R3.2)
/MainControl/SWD_DIO: J28.1, RN7.8 (R1.2)
/MainControl/Satellite_Rx: J31.1, U2.14 (T1OUT)
/MainControl/Satellite_Tx: J31.2, U2.13 (R1IN)
/MainControl/Speed_Bit0: J27.2, R46.2, RN22.6 (R3.2)
/MainControl/Speed_Bit1: J27.3, R47.2, RN22.7 (R2.2)
/MainControl/Speed_Bit2: J27.4, R48.2, RN22.8 (R1.2)
/MainControl/TIM4_CH3: J8.1, RN18.8 (R1.2)
/MainControl/TIM4_CH4: J9.1, RN5.1 (R1.1)
/MainControl/TIM15_CH1: J7.1, RN21.6 (R3.2)
/MainControl/TIM15_CH2: J6.1, RN21.8 (R1.2)
/MainControl/UART1_DE: RN7.7 (R2.2), U13.2 (~RE), U13.3 (DE)
/MainControl/UART1_RX: R10.2, RN7.6 (R3.2), U13.1 (R)
/MainControl/UART1_TX: RN7.5 (R4.2), U13.4 (D)
/MainControl/UART2_DE: RN8.5 (R4.2), U14.2 (~RE), U14.3 (DE)
/MainControl/UART2_RX: R14.2, RN8.7 (R2.2), U14.1 (R)
/MainControl/UART2_TX: RN8.6 (R3.2), U14.4 (D)
/MainControl/UART3_DE: RN18.7 (R2.2), U15.2 (~RE), U15.3 (DE)
/MainControl/UART3_RX: R18.2, RN18.6 (R3.2), U15.1 (R)
/MainControl/UART3_TX: RN18.5 (R4.2), U15.4 (D)
/MainControl/UART4_CTS: RN14.7 (R2.2), U16.15 (CTS)
/MainControl/UART4_RTS: RN14.8 (R1.2), U16.13 (RTS)
/MainControl/UART4_RX: RN10.7 (R2.2), U16.5 (RXD)
/MainControl/UART4_TX: RN10.8 (R1.2), U16.4 (TXD)
/MainControl/UART5_RX: J19.2, RN11.5 (R4.2)
/MainControl/UART5_TX: J19.3, RN11.6 (R3.2)
/MainControl/UART7_RX: J4.1, RN16.5 (R4.2), U2.12 (R1OUT)
/MainControl/UART7_TX: J4.2, RN16.6 (R3.2), U2.11 (T1IN)
/MainControl/UART8_RX: J22.1, RN14.6 (R3.2)
/MainControl/UART8_TX: RN14.5 (R4.2)
/MainControl/VCAP: C60.1, C61.1, U1.48 (VCAP), U1.73 (VCAP)
/MainControl/VREF+: C62.1, L2.1, U1.20 (VREF+)
BUZZER: R41.2, R42.1, U1.22 (PA0)
GND: C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C16.2, C17.2, C18.2, C20.2, C27.2, C46.2, C52.2, C54.2, C55.2, C56.2, C57.2, C58.2, C59.2, C60.2, C61.2, C62.2, C66.2, C70.2, C71.2, C72.2, C73.1, C76.2, C84.2, C85.2, C86.2, C87.2, C88.2, C120.2, C121.2, C122.2, C123.2, C124.2, C125.2, D1.3 (A), D8.3 (common), D9.3 (common), D10.3 (common), D23.1 (K), D33.1 (K), D35.2 (A2), J1.6 (VSS), J2.2, J3.MP (MountPin), J4.4, J4.MP (MountPin), J5.3, J5.MP (MountPin), J6.3, J7.3, J8.3, J9.3, J11.MP (MountPin), J12.MP (MountPin), J13.MP (MountPin), J14.MP (MountPin), J15.MP (MountPin), J16.MP (MountPin), J17.MP (MountPin), J18.MP (MountPin), J19.4, J19.MP (MountPin), J20.4, J21.4, J21.MP (MountPin), J22.3, J23.7, J23.MP (MountPin), J24.4, J24.MP (MountPin), J25.5, J25.MP (MountPin), J26.3, J26.MP (MountPin), J27.5, J27.MP (MountPin), J28.3, J28.MP (MountPin), J29.3, J29.MP (MountPin), J30.3, J30.MP (MountPin), J31.3, J31.MP (MountPin), Q1.2 (S), R1.2, R13.2, R17.2, R21.2, R25.1, R28.1, R31.1, R32.1, R41.1, R61.2, RN6.4 (R4.1), RN6.5 (R4.2), RN11.1 (R1.1), RN11.2 (R2.1), RN11.7 (R2.2), RN11.8 (R1.2), RN20.1 (R1.1), RN20.8 (R1.2), RN21.2 (R2.1), RN21.4 (R4.1), RN21.5 (R4.2), RN21.7 (R2.2), SW1.2, U1.10 (VSS), U1.19 (VSSA), U1.26 (VSS), U1.49 (VSS), U1.74 (VSS), U1.99 (VSS), U2.15 (GND), U4.2 (GND), U4.8 (STB), U6.2, U13.5 (GND), U14.5 (GND), U15.5 (GND), U16.2 (GND), U16.17 (GND), Y1.2, Y1.4; also elsewhere on the board
unnamed: BZ2.1 (+), C67.2, D12.2 (A), Q1.3 (D)
unnamed: D11.2 (A), R22.2
unnamed: D23.2 (A), R30.1
unnamed: D32.2 (A), R85.2
unnamed: D33.2 (A), R86.2
unnamed: C72.1, J1.10 (SHIELD), R1.1
unnamed: F3.2, J20.1
unnamed: F2.1, J28.4
unnamed: Q1.1 (G), R42.2
unnamed: R58.2, R59.2, SW1.1
unnamed: R60.2, R61.1, SW2.1
unnamed: C126.1, U2.1 (C1+)
unnamed: C126.2, U2.3 (C1-)
unnamed: C127.1, U2.4 (C2+)
unnamed: C127.2, U2.5 (C2-)
unnamed: R23.2, U16.9 (VBUS)

Notes on the sheet:
IOCtrl_Pump
SPI
Stepper Motor
GPIO
SBUS
Crystal
RS485_Bus1
USB-TTL
Transceiver
RS485_Bus3
迭代意见: 接口用竖插的 电源分少一些别再这块板上画了 UART2-485 A layout少一根线 板载imu不一定要了 IMU封装有问题阻焊层没去掉 把其他引脚也引出来 SD卡测试完再迭代还是直接迭 UART3有个丝印反了 舵机pwm接口丝印反了 UART8 TX RX反了！ 卫星模块加上板载RS232? 24vADC 可以删了留作GPIO口 加上debug的buzzer和led i2c小屏幕？ 3.3v电源加二极管 避免swd倒灌电源
卫星通信模块需要隔离3.3v和5v供电 需要用1.5A DCDC
RS485_Bus2
I2C
BOOT0
NRST
LED
ver1.1 development log: 12v的tvs选型错了 会短路
SWD
Satellite Com
Servo
原有imu接口 换成预留SPI接口 SPI1备有两个GPIO接口
UART5_IMU
BUZZER
ADC
SD Card
STM32H7有软件反转UART电平功能，不需要反转SBUS电平
System Core
ver1.1 迭代更改: 还没有用的RS422接口换成UART 接IMU 原有imu接口留出来接口 当作闲置SPI1 多引出来了一个SPI2 UART8 TX RX反了 软件能mux TxRx invert 索性不改了 48-24v DC-DC 电路删掉 空间上过于冗余 12v电机DCDC删掉 IMU的LDO供电删掉 卫星通讯3v3 LDO删掉 DCDC模块也可以后面再额外增加电源板 引出LPUART1 多一个UART口空闲 引出I2C2 加TIM15驱动舵机 PE4,PC13,PC14,PC15 GPIO驱动泵 电阻5v上拉符合电平标准 卫星模块供电换成12v 留有功率冗余 加入蜂鸣器 T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
CAN1
步进电机其实也可以自己找驱动芯片，可能可以再缩小一些体积 但是选芯片和迭代也要一定时间，留着引脚后面有时间有必要再做了
LPUART1

Parts:
C1, C26, C37, C40, C81: 100n; C_0603_1608Metric
C2, C25, C80: 47p; C_0603_1608Metric
C3, C24, C79: 4.7n; C_0603_1608Metric
C14, C15, C28, C29, C30, C31, C32, C33, C34, C35, C75, C77, C78, C82, C83: 10u; C_1206_3216Metric
C19: 47u; CP_EIA-3216-18_Kemet-A_Pad1.58x1.35mm_HandSolder
C21, C22, C23, C47, C48, C49: 47u; CP_Radial_D6.3mm_P2.50mm
C36, C39, C51, C53, C63, C64, C65: 10u; C_0603_1608Metric
C38: 10n; C_0603_1608Metric
C50: 20p; C_0603_1608Metric
D2: SMCJ28A; D_SMC
D3, D4, D5: ST20100L; D_PowerDI-5
D13: DSS34; D_SMF
D15, D19: SMAJ5.0A; D_SMA
D16, D17: SMF3.3v; D_SMF
D20: SMAJ7.5A; D_SMA
D22: LED_Red; LED_0603_1608Metric
D25, D30, D31: LED_Green; LED_0603_1608Metric
D26: LED_Pink; LED_0603_1608Metric
D27: LED_Blue; LED_0603_1608Metric
F1: Fuse; Fuseholder_Littelfuse_Nano2_157x
J10: Conn_01x02; AMASS_XT30U-M_1x02_P5.0mm_Vertical
L1, L4, L5: 7.2u; L_Sunlord_MWSA0603S
L3: 4u7; L_Sunlord_MWSA0402S
R33, R38, R45: 243k; R_0603_1608Metric
R34, R37, R44: 16.9k; R_0603_1608Metric
R35: 47k; R_0603_1608Metric
R36, R40, R70, R72, R78, R83, R84: 10k; R_0603_1608Metric
R39: 53.6k; R_0603_1608Metric
R69: 140k; R_0603_1608Metric
R71: 82.5k; R_0603_1608Metric
R75: 100k; R_0603_1608Metric
R79, R80: 1k; R_0603_1608Metric
U7, U8, U9: TPS54560BDDA; Texas_R-PDSO-G8_EP2.95x4.9mm_Mask2.4x3.1mm_ThermalVias
U10: RS3236; SOT-23-5
U17: RY3430; SOT-23-5

Connections:
+3.3V_IO: C39.1, C40.1, D17.1 (A1), R80.1, U10.5 (OUT); also elsewhere on the board
+3.3V_MCU: D13.1 (K), R79.1; also elsewhere on the board
+5V: C14.1, C15.1, C21.1, C22.1, C36.1, C37.1, C51.1, C53.1, D15.1 (A1), L1.2, R39.1, R78.1, U10.1 (IN), U10.3 (EN), U17.1 (EN), U17.4 (VIN); also elsewhere on the board
+7.4v_Servo: C47.1, C49.1, C82.1, C83.1, D20.1 (A1), L5.2, R71.1, R84.1; also elsewhere on the board
+12V_SatellieCom: C23.1, C28.1, C35.1, C48.1, D19.1 (A1), L4.2, R69.1, R83.1; also elsewhere on the board
+48V: C29.1, C30.1, C31.1, C32.1, C33.1, C34.1, C75.1, C77.1, C78.1, D2.1 (A1), F1.2, R75.1, U7.2 (VIN), U8.2 (VIN), U9.2 (VIN); also elsewhere on the board
/Power/5v_FB: R39.2, R40.1, U7.5 (FB)
/Power/7.4v_FB: R71.2, R72.1, U9.5 (FB)
/Power/SATCom_12v_FB: R69.2, R70.1, U8.5 (FB)
GND: C2.1, C3.1, C14.2, C15.2, C19.2, C21.2, C22.2, C23.2, C24.1, C25.1, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C47.2, C48.2, C49.2, C51.2, C53.2, C63.2, C64.2, C65.2, C75.2, C77.2, C78.2, C79.1, C80.1, C82.2, C83.2, D2.2 (A2), D3.2 (A), D4.2 (A), D5.2 (A), D15.2 (A2), D16.2 (A2), D17.2 (A2), D19.2 (A2), D20.2 (A2), D22.1 (K), D25.1 (K), D26.1 (K), D27.1 (K), D30.1 (K), D31.1 (K), J10.1, R33.2, R36.2, R38.2, R40.2, R45.2, R70.2, R72.2, U7.7 (GND), U7.9 (GND), U8.7 (GND), U8.9 (GND), U9.7 (GND), U9.9 (GND), U10.2 (GND), U17.2 (GND); also elsewhere on the board
unnamed: C3.2, R34.1
unnamed: C24.2, R37.1
unnamed: C79.2, R44.1
unnamed: C1.2, D3.1 (K), L1.1, U7.8 (SW)
unnamed: C26.2, D4.1 (K), L4.1, U8.8 (SW)
unnamed: C81.2, D5.1 (K), L5.1, U9.8 (SW)
unnamed: C19.1, C50.1, C63.1, C64.1, C65.1, D13.2 (A), D16.1 (A1), L3.2, R35.1
unnamed: D22.2 (A), R75.2
unnamed: D25.2 (A), R78.2
unnamed: D26.2 (A), R79.2
unnamed: D27.2 (A), R80.2
unnamed: D30.2 (A), R83.2
unnamed: D31.2 (A), R84.2
unnamed: F1.1, J10.2
unnamed: C1.1, U7.1 (BOOT)
unnamed: C2.2, R34.2, U7.6 (COMP)
unnamed: R33.1, U7.4 (RT/CLK)
unnamed: C26.1, U8.1 (BOOT)
unnamed: C25.2, R37.2, U8.6 (COMP)
unnamed: R38.1, U8.4 (RT/CLK)
unnamed: C81.1, U9.1 (BOOT)
unnamed: C80.2, R44.2, U9.6 (COMP)
unnamed: R45.1, U9.4 (RT/CLK)
unnamed: C38.1, U10.4 (BP)
unnamed: C50.2, R35.2, R36.1, U17.5 (FB)
unnamed: L3.1, U17.3 (SW)

Notes on the sheet:
可能要出来的线上或者板子fuse后加个开关 24v电源先换成28A
